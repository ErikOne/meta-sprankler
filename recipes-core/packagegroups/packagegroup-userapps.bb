SUMMARY = "User applications"
LICENSE = "MIT"

inherit packagegroup

